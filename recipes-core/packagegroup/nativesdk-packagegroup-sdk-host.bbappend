RDEPENDS_${PN} += " \
    nativesdk-capnproto-compiler \
    nativesdk-cmake-dev \
"
